## Kconfig
```kconfig
# SPDX-License-Identifier: Apache-2.0
config HAL_BESTECHNIC_AVAILABLE
	bool
	default y
```
